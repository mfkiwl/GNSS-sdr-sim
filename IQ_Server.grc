options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_c
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2600000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket
      import os
      from collections import deque
      from functools import reduce

      class myConn:
          def __init__(self, server_port):
              self.server_port = server_port
              self.isOpen = False
              self.buffer = deque()
          
          def connect(self):
              sock = socket.socket(socket.AF_INET, socket.SOCK_STREAM)  
              sock.bind(('127.0.0.1', self.server_port))  
              sock.listen(5)
              print("waiting for connection")
              connection,address = sock.accept()
              print("connected") 
              self.connection = connection
              self.address = address
              self.isOpen= True
              sock.setblocking(False)
          
          def reciveComplex(self):
              buf = self.connection.recv(4096)
              recived_ints = np.frombuffer(buf, dtype=np.int8)
              output = recived_ints.astype(np.float32).view(np.complex64)
              return output

          def fillOwnBuffer(self):
            if len(self.buffer)>400:
                return
            buf = None
            try:
                buf = self.reciveComplex()
                self.buffer.append(buf)
                while len(buf)==2048:
                    buf = self.reciveComplex()
                    self.buffer.append(buf)
            except socket.timeout(e):
                self.buffer.append(buf)
          
          def fillOutput(self, output_items):
              s = 0
              while True:
                  v = len(output_items[0])
                  b = len(self.buffer[0])
                  if v-s<b:
                      output_items[0][s:] = self.buffer[0][0:v-s]
                      self.buffer[0] = self.buffer[0][v-s:]
                      return v
                  elif v-s>b:
                      output_items[0][s:b+s] = self.buffer[0]
                      self.buffer.popleft()
                      if len(self.buffer)==0:
                          return s+b
                      s = b
                  elif v-s==b:
                      output_items[0][s:b+s] = self.buffer[0]
                      self.buffer.popleft()
                      return s+b # = v
                      
          def bufferSize(self):
              return reduce(lambda a,b: a+len(b), self.buffer, 0)
          
          def shortPause(self):
              self.connection.send(b'P')

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, server_port=12345):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='IQ Input Server',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.complex64]#, np.uint32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.server_port = server_port
              #self.isConnected=False
              #self.spare = None
              self.conn = myConn(server_port)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if not self.conn.isOpen:
                  self.conn.connect()
              self.conn.fillOwnBuffer()
              #if self.conn.bufferSize()>2600000: # if buffer is larger than 1 second
              #    self.conn.shortPause()
              #    #print("pause")
              n = self.conn.fillOutput(output_items)
              #output_items[1][0:n] = np.repeat(self.conn.bufferSize(), n)
              return n
              

              #if not self.isConnected:
              #    sock = socket.socket(socket.AF_INET, socket.SOCK_STREAM)  
              #    sock.bind(('127.0.0.1', self.server_port))  
              #    sock.listen(5)
              #    print("waiting for connection")
              #    connection,address = sock.accept()
              #    print("connected") 
              #    self.connection = connection
              #    self.address = address
              #    self.isConnected = True
              #output = None
              #if self.spare is not None:
              #    output = self.spare
              #else:
              #    buf = self.connection.recv(4096) # 2*4*(2**15)
              #    #print("buffer size:", len(buf), buf[0:16])
              #    recived_ints = np.frombuffer(buf, dtype=np.int8)
              #    n = len(recived_ints)
              #    #print("recived:", n, recived_ints[0:8])
              #    output = recived_ints.astype(np.float32).view(np.complex64)
              #self.spare = None
              #k = n//2
              #if k>output_items[0].shape[0]:
              #    v = output_items[0].shape[0]
              #    output_items[0][0:v] = output[0:v]
              #    self.spare = output[v:]
              #else:
              #    output_items[0][0:k] = recived_ints.astype(np.float32).view(np.complex64)
              #    #output_items[0][0:n] = np.zeros(n, dtype=np.complex64)
              #    #print("returning")
              #    return len(output_items[0])
    server_port: '12345'
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: '30.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq_c
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: ip:192.168.1.131
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_c
    fftsize: '8192'
    type: complex
  states: {state: disabled}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle2_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', blocks_probe_rate_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, '0', iio_fmcomms2_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
