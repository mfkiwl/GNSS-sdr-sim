options:
  parameters:
    generate_options: no_gui
    id: networkedSDR
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_c
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '7000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\inetpub\wwwroot\gps_sdr_sim_2_6_MHz.bin
    repeat: 'False'
    type: byte
    vlen: '2'
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Mike\Desktop\Thesis\GNSS-sdr-sim\data\OutputIQ.sigmf-data
    repeat: 'False'
    type: byte
    vlen: '2'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: '30.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq_c
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: ip:192.168.2.19
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_probe_rate_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', iio_fmcomms2_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
